Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-07-24T15:57:12+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi_M2-M9_INT-EN:EMCM-M7-6.6, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi_M2-M9_INT-EN:EMCM-M7-6.6:284160
In: Level 1
Type - Material: Color RGB 181-166-066, Color RGB 040-040-040 (2), Color RGB 182-182-182, Color RAL 1003, Color RGB 115-115-115, Color RGB 255-255-255, Color RGB 055-055-055, Color RGB 200-200-200 (2), Color RGB 255-000-000, Color RGB 200-000-000
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 1014 mm; Height: 1334.5 mm; Overflow Diameter: 38.1 mm; Pressure Diameter: 38.1 mm; Refill Diameter: 12.7 mm; Suction Diameter: 38.1 mm; Use Nominal Diameter: yes; Width: 964 mm
Type - Electrical - Loads - Power: 4600 W
Type - Electrical Engineering - Phase: 1; Voltage: 400 V
Type - Identity Data - Article Description: SpiroExpand MultiControl Modular Maxi; Article Type: EMCM-M7-6.6; Base Family Version: 25.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: SpiroExpand MultiControl Modular Maxi; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 25.08; GLN: 8717811000007; GTIN: 8717811042847; Manufacturer: Spirotech; Manufacturer Art. No.: EMCM-M7-6.6; Manufacturer URL: https://www.spirotech.com/products/spiroexpand-pressurization/spiroexpand-multicontrol-modular-maxi-200; MEPcontent Class: VACUUM_DEGASSER; Model: EMCM-M7-6.6; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: SpiroExpand; Revit Version: 2023; Type Name: EMCM-M7-6.6; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Red: Color RGB 200-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Other - Category: Mechanical Equipment; 141: no; 178: yes; 220: no; Bottom Plate: 657.5 mm; C: 365.35 mm; D: 1179 mm; E: 525 mm; F: 1006 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi_M2-M9_INT-EN; Flange: no; G: 153 mm; Height to Rectangle: 12 mm; I: 118 mm; J: 110 mm; Legs Height: 3 mm; Legs Visibility 1: no; Legs Visibility 2: yes; Middle Plate: 438.5 mm; Mintenance Pump Depth: 293.5 mm; Overflow Pipe Length: 16 mm; Overflow Pipe Nominal: 38.1 mm; Overflow Pipe Radius: 24.15 mm; Pipe Angle: 11 deg; Pipe Depth: 93 mm; Pipe Length: 781.6 mm; Pressure Depth: 116.5 mm; Pressure Pipe Nominal: 38.1 mm; Pressure Pipe Radius: 24.15 mm; Pump Body 1: 157.4 mm; Pump Body 2: 24 mm; Pump Body Height: 498.1 mm; Pumps Distance: 738 mm; Rear Pump: no; Rectangle Depth: 109 mm; Rectangle Height: 216 mm; Rectangle Width: 268 mm; Refill Depth: 247.5 mm; S10: no; S4-S10: no; S4-S9: yes; Second Top Part: 71.2 mm; Second Type: no; Service Space Plane: 654 mm; Simple Geometry: yes; Suction Pipe Length: 710.47 mm; Suction Pipe Nominal: 38.1 mm; Suction Pipe Radius: 24.15 mm; Top Part of Pump Height: 202.8 mm; Total Width: 1050 mm; Unit Depth: 903.5 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 181-166-066, Color RGB 040-040-040, Color RGB 182-182-182, Color RAL 1003, Color RGB 115-115-115, Color RGB 255-255-255, Color RGB 055-055-055, Color RGB 200-200-200, Color RGB 255-000-000, Color RGB 200-000-000
Pset_BuildingElementProxyCommon - Reference: EMCM-M7-6.6
Pset_EnvironmentalImpactIndicators - Reference: EMCM-M7-6.6
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 15.1749 m2; Volume: 0.541536 m3
Identity Data - Mark: 1
Mechanical - Flow In: 0 m3/s; Pressure Flow: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Hydronic Supply,Power,Hydronic Supply
Other - Angle: 180 deg; Back Clearance Safe: 0 mm; Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi_M2-M9_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Maxi_M2-M9_INT-EN: EMCM-M7-6.6; Front Clearance Safe: 500 mm; Front Pump: yes; Left Clearance Safe: 500 mm; Left Side Pipe: 290 mm; Reference Line Length: 62 mm; Refill Angle: 345.39 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 320 mm; Supply Length: 300 mm; Top Clearance Safe: 500 mm; Type: EMCM-M7-6.6; Type Id: 284113
Phasing - Phase Created: New Construction
Visibility - Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: yes; Right Clearance: 500 mm; Right Side Connection: no; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType
2 x Port_284160 | SOURCE | PIPE | HEATING
Port_284160 | SINK | PIPE | HEATING
Port_284160 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_284160 | SINK | PIPE
